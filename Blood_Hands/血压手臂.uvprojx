# Keil uVision project 血压手臂.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blood_Hands +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\HardWare\adc;.\HardWare\i2c;.\HardWare;..\Blood_Hands
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./: main.c stm32f10x_it.c
  group TASK
    ./HardWare/: Task_init.c Timer_init.c Semaphore_init.c All_Duty_Dispose.c
  group HardWare
    ./HardWare/: bsp_can.c bsp_key.c bsp_usart.c General_GPIO.c
    ./HardWare/adc/: bsp_adc.c
    ./HardWare/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
software components: CMSIS:CORE 5.4.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, RTOS:kernel 3.1.3
